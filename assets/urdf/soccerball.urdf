Commit message: correct ball urdf (friction)

File: assets/urdf/soccerball.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- removed link baseLink
- added link ball, mass 0.37; collision sphere radius=0.1; visual sphere radius=0.1
